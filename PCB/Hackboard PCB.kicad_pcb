# Repository IHateScones/First-Hackpad

File README.md:

# First-Hackpad
This is my first hackpad being made for the Hackclub Blueprint program. This is also my first time using any sort of this software so I am still learning!

# Challenges
This was made in one night and it was my very first time using softwares such as KiCad and Fusion, so don't expect it to be perfect or anything special, but I am proud of it!

# Specifications
1x XIAO rp2040
2x SK6812 Mini LED
4x Cherry MX Switches

# Other Materials
Bottom Case
Top Case
QMK Firmware

## KiCad design PCB/Hackboard PCB.kicad_pcb

Parts:
D1, D2: SK6812MINI; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm
SW1, SW2, SW3, SW4: SW_Push; SW_Cherry_MX_1.00u_PCB
U1: XIAO-RP2040-DIP

Connections:
+5V: D1.4 (VDD), D2.4 (VDD)
GND: D1.2 (VSS), D2.2 (VSS), SW1.1, SW2.1, SW3.1, SW4.1
unnamed: D1.3 (DIN), U1.5 (GPIO6/SDA)
unnamed: D1.1 (DOUT), D2.3 (DIN)
unnamed: SW1.2, U1.8 (GPIO1/RX)
unnamed: SW2.2, U1.9 (GPIO2/SCK)
unnamed: SW4.2, U1.11 (GPIO3/MOSI)
unnamed: SW3.2, U1.10 (GPIO4/MISO)

Board: 2 copper layers, 61.9 x 65.8 mm, 7 parts (0 on the bottom side), 8 nets.
